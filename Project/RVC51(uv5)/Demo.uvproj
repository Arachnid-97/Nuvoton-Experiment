# Keil uVision project Demo.uvproj, settings and files
target Demo_Debug (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\App;..\..\Bsp;..\..\W25Qxx;..\..\Rocker;..\..\WiFi;..\..\Sense;..\..\OLED_libraries;..\..\Font_libraries;..\..\NRF24L01
  link misc: REMOVEUNUSED
  group STARTUP
    ../../App/: STARTUP.A51
  group CMSIS
    ../../App/: N76E003.h
  group Bsp
    ../../Bsp/: bsp.c bsp_uart.c bsp_eeprom.c bsp_time.c bsp_adc.c bsp_exti.c
  group OLED
    ../../OLED_libraries/: oled12864_drv.c oled_extend.c font_array.h oled_font.h
  group Sense
    ../../Sense/: sensors_series.c
  group Rocker
    ../../Rocker/: rocker_comm.c
  group NRF24l
    ../../NRF24L01/: nrf24l01_drv.c
  group User
    ../../App/: main.c task.c
  group Doc
    ../../Doc/: ReadMe.txt
